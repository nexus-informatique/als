require cherokee.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "ef47003355a2e368e4d9596cd070ef23"
SRC_URI[sha256sum] = "ca465ab3772479fc843b38ffc45113bf24d8bfae9185cdd5176b099d5a17feb8"
